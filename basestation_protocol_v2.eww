<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\basestation_protocol_v2.ewp</path>
    </project>
    <batchBuild />
</workspace>
